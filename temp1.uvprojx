# Keil uVision project temp1.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temp1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c ADC.c ADC.h bitwise_operation.h Delay.c Delay.h DIO.c DIO.h DIO_Types.h gptm.c gptm.h LCD.c LCD.h Motor.c Motor.h PushButton.c PushBuuton.h PWM.c PWM.h Sensor.c Sensor.h std_types.h SWCsIncludes.h ultrasonic.c ultrasonic.h SWC1.c SWC1.h SWC2.c SWC2.h SWC3.c SWC3.h SWC4.c SWC4.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
